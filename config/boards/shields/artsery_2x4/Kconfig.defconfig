## config/boards/shields/artsery_2x4/Kconfig.defconfig
```kconfig
config ZMK_USB
    default n

config ZMK_BLE
    default y

config ZMK_KEYBOARD_NAME
    default "artsey_r21"
```
